# Repository yassan802/DRC_POWER2026

File README.md:

緊急停止スイッチ等を使用可能な電源基板です。コンデンサの突入電流の防止やバッテリー電圧、電流の監視を行うことが出来、搭載しているマイコンからの信号でリレーのONOFFが可能になっています。  
↓kicanvas  
https://kicanvas.org/?repo=https%3A%2F%2Fgithub.com%2Fyassan802%2FDRC_POWER2026

## KiCad design DRC_POWER2026.kicad_pcb

Parts:
C3: 10u; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C4: 47u; C_1210_3225Metric_Pad1.33x2.70mm_HandSolder
C5, C18, C19, C22, C23: 0.1u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C14: 1μF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C16: 4.7μF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C20: 4,7μF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C21: 4.7u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
D2, D5: SS2040FL; D_SOD-123F
D13, D14: LED_Small; D_0603_1608Metric_Pad1.05x0.95mm_HandSolder
J1, J2: Conn_01x02; AMASS_XT60PW-F_1x02_P7.20mm_Horizontal
J3: USB_C_Receptacle_USB2.0_16P; USB_C_Receptacle_GCT_USB4105-xx-A_16P_TopMnt_Horizontal
J12: EMG; TerminalBlock_MaiXu_MX126-5.0-02P_1x02_P5.00mm
JP2: BOOT; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
NT1: NetTie_3_Tee; NetTie-3_THT_Pad0.3mm
R1, R2, R21, R24, R26, R28: 5.1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R22: 2.4k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R23: 330; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R29: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R38, R40: R_Small; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
SW1: RESET; SW_SPST_EVQPE1
U3: BP5293-50; SIP3_11.6x8.5mm
U14: R7FA4M1AB3CFM_AA0; QFP50P1200X1200X170-64N; PARTREV 1.1; DigiKey_Part_Number 559-R7FA4M1AB3CFM#AA0-ND

Connections:
7seg_CLK: U14.37 (P112); also elsewhere on the board
+3.3V: C18.2, C21.2, U14.4 (VBATT), U14.20 (VCC_USB)
+5V: C4.1, C5.1, C19.2, C20.1, C22.2, C23.1, D2.1 (K), D5.2 (A), R21.1, R22.2, R24.2, R26.1, R28.1, R38.1, U3.3 (Vout), U14.11 (VCC), U14.21 (VCC_USB_LDO), U14.39 (VCC), U14.56 (AVCC0); also elsewhere on the board
+12V: C3.1, D5.1 (K), J2.2, J12.2, U3.1 (Vin); also elsewhere on the board
+24V: J1.2; also elsewhere on the board
/A4/SDA: U14.47 (P101)
/A5/SCL: U14.48 (P100)
/D0/RX: U14.31 (P301)
/D1/TX: U14.30 (P302)
/D2: U14.43 (P105)
/D3: U14.44 (P104)
/D4/TX: U14.45 (P103)
/D5/RX: U14.46 (P102)
/D6: U14.42 (P106)
/D8: U14.28 (P304)
/D9: U14.29 (P303)
BOOT: JP2.2 (B), R26.2, U14.26 (P201/MD)
DIN: U14.36 (P111); also elsewhere on the board
EMG: J12.1; also elsewhere on the board
GND: C14.1, C16.1, C18.1, C19.1, C20.2, C21.1, C22.1, C23.2, D13.1 (K), D14.1 (K), J3.A1 (GND), J3.A12 (GND), J3.B1 (GND), J3.B12 (GND), J3.SH (SHIELD), JP2.1 (A), NT1.2, R1.2, R2.1, R23.2, R29.2, SW1.2, U14.8 (VSS), U14.17 (VSS_USB), U14.40 (VSS), U14.57 (AVSS0); also elsewhere on the board
GNDPWR_12v: C3.2, C4.2, C5.2, J2.1, NT1.3, U3.2 (GND); also elsewhere on the board
GNDPWR_24v: J1.1, NT1.1; also elsewhere on the board
LED: R40.1, U14.41 (P107)
unnamed: D2.2 (A), J3.A4 (VBUS), J3.A9 (VBUS), J3.B4 (VBUS), J3.B9 (VBUS)
unnamed: D13.2 (A), R38.2
unnamed: D14.2 (A), R40.2
unnamed: J3.A5 (CC1), R1.1
unnamed: J3.B5 (CC2), R2.2
unnamed: C14.2, U14.59 (P010/VREFH0)
unnamed: R24.1, U14.27 (P200)
unnamed: R28.2, R29.1, U14.16 (P407)
unnamed: R22.1, R23.1, U14.49 (P500)
unnamed: C16.2, U14.5 (VCL)
STOP0: U14.34 (P109/TDO/SWO); also elsewhere on the board
STOP1: U14.35 (P110/TDI); also elsewhere on the board
USB_D_N: J3.A7 (D-), J3.B7 (D-), U14.18 (P915/USB_DM)
USB_D_P: J3.A6 (D+), J3.B6 (D+), U14.19 (P914/USB_DP)
VI0: U14.64 (P000); also elsewhere on the board
VI1: U14.53 (P014); also elsewhere on the board
Vol0: U14.63 (P001); also elsewhere on the board
Vol1: U14.62 (P002); also elsewhere on the board
~RESET: R21.2, SW1.1, U14.25 (~RES)

Notes on the sheet:
12vと24vと制御用電源の一点接地

Parts:
C7, C11, C13: 0.1u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C12, C15: 3300u; CP_Radial_D18.0mm_P7.50mm
D9, D10: D_Small; D_SOD-123F
D11: LED_Small; D_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D12: 5.1v; D_SOD-128
J10: VOUT; AMASS_XT60PW-M_1x02_P7.20mm_Horizontal
J11: P_LIGHT; TerminalBlock_MaiXu_MX126-5.0-02P_1x02_P5.00mm
K3: G5V-2; Relay_DPDT_Omron_G5V-2
Q1: DTC143E; SOT-23-3
R6, R11: 1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R17: 10; R_2512_6332Metric_Pad1.40x3.35mm_HandSolder
R18: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R19: 22k,0.1%; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R20: 4.7k,0.1%; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
U1: TLP172AM
U10: A31ASPxxVDC2D; PC795_PCB
U13: ACS772KCB-150B-PFF-T; XDCR_ACS772KCB-150B-PFF-T; PARTREV 21

Connections:
+5V: C11.1, U13.1 (VCC); also elsewhere on the board
+12V: D11.2 (A), K3.8, R19.1, U1.4, U10.1 (30); also elsewhere on the board
EMG: Q1.1 (B); also elsewhere on the board
GND: C7.2, C11.2, C13.2, D12.2 (A), R11.2, R20.2, U13.2 (GND); also elsewhere on the board
GNDPWR_12v: C12.2, C15.2, D9.2 (A), J10.1, J11.2, Q1.2 (E), R18.2, U10.2 (85); also elsewhere on the board
unnamed: D9.1 (K), K3.9, U10.3 (86)
unnamed: D10.2 (A), K3.16, Q1.3 (C)
unnamed: D10.1 (K), K3.1, U1.6
unnamed: D11.1 (K), R18.1
unnamed: C12.1, C15.1, J10.2, J11.1, K3.13, R17.2, U13.4 (IP+), U13.4_1 (IP+), U13.4_2 (IP+), U13.4_3 (IP+), U13.4_4 (IP+), U13.4_5 (IP+), U13.4_6 (IP+), U13.4_7 (IP+), U13.4_8 (IP+), U13.4_9 (IP+), U13.4_10 (IP+), U13.4_11 (IP+), U13.4_12 (IP+), U13.4_13 (IP+), U13.4_14 (IP+), U13.4_15 (IP+), U13.4_16 (IP+)
unnamed: K3.4, R17.1
unnamed: R11.1, U1.3
unnamed: U10.4 (87), U13.5 (IP-), U13.5_1 (IP-), U13.5_2 (IP-), U13.5_3 (IP-), U13.5_4 (IP-), U13.5_5 (IP-), U13.5_6 (IP-), U13.5_7 (IP-), U13.5_8 (IP-), U13.5_9 (IP-), U13.5_10 (IP-), U13.5_11 (IP-), U13.5_12 (IP-), U13.5_13 (IP-), U13.5_14 (IP-), U13.5_15 (IP-), U13.5_16 (IP-)
unnamed: R6.2, U13.3 (VIOUT)
STOP1: U1.1; also elsewhere on the board
VI1: C7.1, R6.1; also elsewhere on the board
Vol1: C13.1, D12.1 (K), R19.2, R20.1; also elsewhere on the board

Notes on the sheet:
プリチャージ抵抗 τ＝10*6600u =0.066=66ms
注意！ リレー２つはちゃんとバッテリー電圧に合わせたコイル電圧の物を用いる 大容量リレー １２ｖ：A31ASP12VDC2D ２４ｖ：A31ASP24VDC2D 小信号リレー １２ｖ：G5V-2 DC12 ２４ｖ：G5V-2 DC２４

Parts:
C6, C9, C10: 0.1u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C8, C17: 3300u; CP_Radial_D18.0mm_P7.50mm
D4, D6: D_Small; D_SOD-123F
D7: LED_Small; D_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D8: 5.1v; D_SOD-128
J7: VOUT; AMASS_XT60PW-M_1x02_P7.20mm_Horizontal
J8: P_LIGHT; TerminalBlock_MaiXu_MX126-5.0-02P_1x02_P5.00mm
K2: G5V-2; Relay_DPDT_Omron_G5V-2
R5, R7: 1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R10: 2.2k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R13: 10; R_2512_6332Metric_Pad1.40x3.35mm_HandSolder
R14: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R15: 22k 0.1%; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R16: 4.7k 0.1%; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
U6: A31ASPxxVDC2D; PC795_PCB
U7, U8: TLP172AM
U9: ACS772KCB-150B-PFF-T; XDCR_ACS772KCB-150B-PFF-T; PARTREV 21

Connections:
+5V: C10.1, U9.1 (VCC); also elsewhere on the board
+24V: D7.2 (A), K2.8, R15.1, U6.1 (30), U7.4; also elsewhere on the board
EMG: U8.1; also elsewhere on the board
GND: C6.2, C9.2, C10.2, D8.2 (A), R7.2, R16.2, U9.2 (GND); also elsewhere on the board
GNDPWR_12v: R10.2; also elsewhere on the board
GNDPWR_24v: C8.2, C17.2, D4.2 (A), D6.2 (A), J7.1, J8.2, K2.16, R14.2, U6.2 (85); also elsewhere on the board
unnamed: D4.1 (K), K2.9, U6.3 (86)
unnamed: D6.1 (K), K2.1, U8.6
unnamed: D7.1 (K), R14.1
unnamed: C8.1, C17.1, J7.2, J8.1, K2.13, R13.2, U9.5 (IP-), U9.5_1 (IP-), U9.5_2 (IP-), U9.5_3 (IP-), U9.5_4 (IP-), U9.5_5 (IP-), U9.5_6 (IP-), U9.5_7 (IP-), U9.5_8 (IP-), U9.5_9 (IP-), U9.5_10 (IP-), U9.5_11 (IP-), U9.5_12 (IP-), U9.5_13 (IP-), U9.5_14 (IP-), U9.5_15 (IP-), U9.5_16 (IP-)
unnamed: K2.4, R13.1
unnamed: R7.1, U7.3
unnamed: R10.1, U8.3
unnamed: U6.4 (87), U9.4 (IP+), U9.4_1 (IP+), U9.4_2 (IP+), U9.4_3 (IP+), U9.4_4 (IP+), U9.4_5 (IP+), U9.4_6 (IP+), U9.4_7 (IP+), U9.4_8 (IP+), U9.4_9 (IP+), U9.4_10 (IP+), U9.4_11 (IP+), U9.4_12 (IP+), U9.4_13 (IP+), U9.4_14 (IP+), U9.4_15 (IP+), U9.4_16 (IP+)
unnamed: U7.6, U8.4
unnamed: R5.2, U9.3 (VIOUT)
STOP0: U7.1; also elsewhere on the board
VI0: C6.1, R5.1; also elsewhere on the board
Vol0: C9.1, D8.1 (K), R15.2, R16.1; also elsewhere on the board

Notes on the sheet:
プリチャージ抵抗 τ＝10*6600u =0.066=66ms
注意！ リレー２つはちゃんとバッテリー電圧に合わせたコイル電圧の物を用いる 大容量リレー １２ｖ：A31ASP12VDC2D ２４ｖ：A31ASP24VDC2D 小信号リレー １２ｖ：G5V-2 DC12 ２４ｖ：G5V-2 DC２４

Parts:
C1: 0.1u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C2: 47u; C_1210_3225Metric_Pad1.33x2.70mm_HandSolder
U5, U15, U16, U17, U18, U19, U20, U21, U22, U23, U24, U25: OSL10326-L; OSL10326-LX
U26: TM1640; SOP-28_8.4x18.16mm_P1.27mm

Connections:
7seg_CLK: U26.8 (CLK); also elsewhere on the board
+5V: C1.1, C2.1, U26.17 (VDD); also elsewhere on the board
A: U5.1 (A), U15.1 (A), U16.1 (A), U17.1 (A), U18.1 (A), U19.1 (A), U20.1 (A), U21.1 (A), U22.1 (A), U23.1 (A), U24.1 (A), U25.1 (A), U26.9 (SEG1)
B: U5.10 (B), U15.10 (B), U16.10 (B), U17.10 (B), U18.10 (B), U19.10 (B), U20.10 (B), U21.10 (B), U22.10 (B), U23.10 (B), U24.10 (B), U25.10 (B), U26.10 (SEG2)
C: U5.8 (C), U15.8 (C), U16.8 (C), U17.8 (C), U18.8 (C), U19.8 (C), U20.8 (C), U21.8 (C), U22.8 (C), U23.8 (C), U24.8 (C), U25.8 (C), U26.11 (SEG3)
D: U5.5 (D), U15.5 (D), U16.5 (D), U17.5 (D), U18.5 (D), U19.5 (D), U20.5 (D), U21.5 (D), U22.5 (D), U23.5 (D), U24.5 (D), U25.5 (D), U26.12 (SEG4)
DIN: U26.7 (DIN); also elsewhere on the board
DP: U5.7 (DP), U15.7 (DP), U16.7 (DP), U17.7 (DP), U18.7 (DP), U19.7 (DP), U20.7 (DP), U21.7 (DP), U22.7 (DP), U23.7 (DP), U24.7 (DP), U25.7 (DP), U26.16 (SEG8)
E: U5.4 (E), U15.4 (E), U16.4 (E), U17.4 (E), U18.4 (E), U19.4 (E), U20.4 (E), U21.4 (E), U22.4 (E), U23.4 (E), U24.4 (E), U25.4 (E), U26.13 (SEG5)
F: U5.2 (F), U15.2 (F), U16.2 (F), U17.2 (F), U18.2 (F), U19.2 (F), U20.2 (F), U21.2 (F), U22.2 (F), U23.2 (F), U24.2 (F), U25.2 (F), U26.14 (SEG6)
G: U5.3 (G), U15.3 (G), U16.3 (G), U17.3 (G), U18.3 (G), U19.3 (G), U20.3 (G), U21.3 (G), U22.3 (G), U23.3 (G), U24.3 (G), U25.3 (G), U26.15 (SEG7)
GND: C1.2, C2.2, U26.6 (GND); also elsewhere on the board
GRID1: U17.6 (CC), U17.9 (CC), U26.18 (GRID1)
GRID2: U21.6 (CC), U21.9 (CC), U26.19 (GRID2)
GRID3: U25.6 (CC), U25.9 (CC), U26.20 (GRID3)
GRID4: U24.6 (CC), U24.9 (CC), U26.21 (GRID4)
GRID5: U22.6 (CC), U22.9 (CC), U26.22 (GRID5)
GRID6: U23.6 (CC), U23.9 (CC), U26.23 (GRID6)
GRID7: U15.6 (CC), U15.9 (CC), U26.24 (GRID7)
GRID8: U16.6 (CC), U16.9 (CC), U26.25 (GRID8)
GRID9: U18.6 (CC), U18.9 (CC), U26.26 (GRID9)
GRID10: U19.6 (CC), U19.9 (CC), U26.27 (GRID10)
GRID11: U20.6 (CC), U20.9 (CC), U26.28 (GRID11)
GRID12: U5.6 (CC), U5.9 (CC), U26.1 (GRID12)

Board: 4 copper layers, 100.0 x 100.0 mm, 95 parts (39 on the bottom side), 70 nets.

## Commit log

2026-05-11 second commit
2026-05-11 Third commit
2026-05-12 4th commit
2026-05-12 5th commit
